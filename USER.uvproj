# Keil uVision project USER.uvproj, settings and files
target 片内EEPROM实验-串口菜单控制 (MCS-51)
  device: STC12C5A60S2 STC12C5A16S2 Series
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: USER +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Files
    ./SOURCES/: STARTUP.A51 main.c PWM.c STCEEPROM.C Uart.c LED3.C NTC.c pid.c timer.c key.c
